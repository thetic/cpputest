# IAR project CppUTestExtTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\..\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: CppUTestExtTest.out
  ILINK.IlinkIcfFile: CppUTestExtTest.icf
  ILINK.IlinkAdditionalLibs: Debug\Exe\CppUTest.a; Debug\Exe\CppUTestExt.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.IccLang: 0
  group tests
    ../../tests/CppUTestExt/: AllTests.cpp
    tests/: iar_argc_argv.c
  group tests/passing
    ../../tests/CppUTestExt/: CodeMemoryReporterTest.cpp ExpectedFunctionsListTest.cpp GMockTest.cpp GTest1Test.cpp GTest2ConvertorTest.cpp IEEE754PluginTest.cpp IEEE754PluginTest_c.c IEEE754PluginTest_c.h MemoryReportAllocatorTest.cpp MemoryReporterPluginTest.cpp MemoryReportFormatterTest.cpp MockActualCallTest.cpp MockCallTest.cpp MockCheatSheetTest.cpp MockComparatorCopierTest.cpp MockExpectedCallTest.cpp MockFailureReporterForTest.cpp MockFailureReporterForTest.h MockFailureTest.cpp MockHierarchyTest.cpp MockNamedValueTest.cpp MockParameterTest.cpp MockPluginTest.cpp MockReturnValueTest.cpp MockStrictOrderTest.cpp MockSupport_cTest.cpp MockSupport_cTestCFile.c MockSupport_cTestCFile.h MockSupportTest.cpp OrderedTestTest.cpp OrderedTestTest.h OrderedTestTest_c.c
